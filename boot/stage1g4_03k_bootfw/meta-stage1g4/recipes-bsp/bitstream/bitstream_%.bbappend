# Supply the flat GEM2/J10B PL design to the generic virtual/bitstream
# provider without depending on an absolute checkout path.
BITSTREAM_PATH := "${THISDIR}/../../../artifacts/stage1g4_03m6_tx_frame_buffer.bit"
