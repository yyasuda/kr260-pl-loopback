# Kria enables fpga-overlay and therefore omits the bitstream from BOOT.bin
# by default.  This project uses a boot-time flat PL design instead.
BIF_BITSTREAM_ATTR = "bitstream"
